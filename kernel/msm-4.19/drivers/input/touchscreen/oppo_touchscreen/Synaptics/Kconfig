## kernel/msm-4.19/drivers/input/touchscreen/oppo_touchscreen/Synaptics/Kconfig
```kconfig
source "drivers/input/touchscreen/oppo_touchscreen/Synaptics/Syna_tcm_oncell/Kconfig"
```
